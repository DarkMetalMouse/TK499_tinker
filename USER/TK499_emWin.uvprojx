# Keil uVision project TK499_emWin.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: tk499 +hex
  AfterMake: fromelf.exe --bin -o  ..//@L.bin  ../OBJ/@L.axf
  c flags: Optim=1 OneElfS=1
  c misc: --no-multibyte-chars
  c include: ..\CMSIS_and_startup;..\CMSIS_and_startup\CMSIS;..\Hardware\UART;..\USER;..\emWin\Config;..\emWin\Include;..\picture;..\Hardware\LCD;..\Hardware\touch;..\FAT_FS;..\Hardware\SDIO;..\Hardware\RCC;..\Hal_lib\inc;..\Hardware\TK499_GPIO;..\Hardware\TK499_timer;..\Hardware\TK499_I2C;..\Hardware\TK499_QSPI;..\font
  memory RVCT4: ROM 0x70020000 size 0x200000
  memory RVCT9: RAM 0x70220000 size 0x5dffff
  scatter file: ..\OBJ\tk499.sct
  group CMSIS_startup
    ../CMSIS_and_startup/: startup_Tk499.s tk499.h sys.c
  group USER
    ./: main.c
  group Hardware
    ../Hardware/SDIO/: SDIO.c sdio_sdcard.c
    ../Hardware/touch/: touch_RTP.c touch_CTP.c
    ../Hardware/TK499_I2C/: TK499_I2C.c
    ../Hardware/TK499_timer/: TK499_timer.c
    ../Hardware/TK499_GPIO/: TK499_GPIO.c
    ../Hardware/TK499_QSPI/: qspi_fun.c QSPI_REG.c
    ../Hardware/UART/: UART.c
    ../Hardware/LCD/: Tiky_LCD_APP.c
  group font
    ../font/: HZ_HWXW24.c Font_Num64.c xbf_font.c
  group emWin
    ../emWin/Config/: LCDCONF.C GUICONF.C GUIDRV_Template.c GUI_CM4F_L.lib
    ../emWin/Include/: GUIConf.h GUIDRV_Lin.h
    ../emWin/: GUI.C
  group Tutorial
    ./Tutorial/: COLOR_ShowColorBar.c WIDGET_NumPad.c WIDGET_Effect.c MEMDEV_AutoDev.c WIDGET_ButtonRound.c
    ./Tutorial/SKINNING_NestedModal/: SKINNING_NestedModal.c
  group ATM
    ./ATM/: AA2_21.c AA2_32.c AA4_24.c AA4_32.c bmBlueBlack.c bmCashTerminal.c bmDashboard.c bmSeggerLogoBlue.c CashTerminal.c Dashboard.c Logo_AmericanExpress.c Logo_Cirrus.c Logo_ECCard.c Logo_GeldKarte.c Logo_Maestro.c Logo_MasterCard.c Logo_Segger.c Logo_SeggerLarge.c Logo_SeggerSmall.c Logo_VisaCard.c MainTask.c
  group FAT_FS
    ../FAT_FS/: diskio.c ff.c
  group Hal_lib
    ../Hal_lib/src/: HAL_gpio.c HAL_rcc.c HAL_uart.c HAL_exti.c HAL_tim.c HAL_misc.c HAL_i2c.c
  group README
    ../: readme.txt
